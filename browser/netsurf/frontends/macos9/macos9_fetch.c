/*
 * MacSurf - macos9_fetch.c
 * HTTP fetch via Open Transport, Classilla/LDAP tcp.c pattern:
 * Gestalt check, InContext init with kInitOTForApplicationMask,
 * notifier + async OTConnect + WaitNextEvent poll, then sync Snd/Rcv.
 */

#include <stdlib.h>
#include <string.h>
#include <stdio.h>

#include "utils/errors.h"
#include "utils/log.h"
#include "netsurf/fetch.h"
#include "macos9/macos9.h"

#ifdef __MACOS9__
#include <Gestalt.h>
#include <Events.h>
#include <OpenTransport.h>
#include <OpenTptInternet.h>
#endif

#ifndef kInitOTForApplicationMask
#define kInitOTForApplicationMask 0x00000002
#endif

#define MACSURF_PROXY_HOST "116.202.231.103"
#define MACSURF_PROXY_PORT 8765

static const char *macos9_fetch_filetype(const char *unix_path)
{
	const char *ext;
	if (unix_path == NULL) return "application/octet-stream";
	ext = strrchr(unix_path, '.');
	if (ext == NULL) return "application/octet-stream";
	ext++;
	if (strcasecmp(ext, "html") == 0 || strcasecmp(ext, "htm") == 0)
		return "text/html";
	if (strcasecmp(ext, "css") == 0) return "text/css";
	if (strcasecmp(ext, "png") == 0) return "image/png";
	if (strcasecmp(ext, "gif") == 0) return "image/gif";
	if (strcasecmp(ext, "txt") == 0) return "text/plain";
	return "application/octet-stream";
}

static struct nsurl *macos9_fetch_get_resource_url(const char *path)
{
	(void)path;
	return NULL;
}

static char *macos9_fetch_mimetype(const char *ro_path)
{
	return strdup(macos9_fetch_filetype(ro_path));
}

#ifdef __MACOS9__

typedef struct {
	unsigned char connected;
	unsigned char terminated;
} MacSurfOTState;

static pascal void macos9_ot_notifier(void *context, OTEventCode event,
		OTResult result, void *cookie)
{
	MacSurfOTState *state = (MacSurfOTState *)context;
	(void)result;
	(void)cookie;
	switch (event) {
	case T_CONNECT:    state->connected  = 1; break;
	case T_DISCONNECT: state->terminated = 1; break;
	case T_ORDREL:     state->terminated = 1; break;
	default: break;
	}
}

#endif /* __MACOS9__ */

void
macos9_fetch_url(const char *url, struct gui_window *gw,
		void (*callback)(struct gui_window *gw,
			const char *data, long len, int status))
{
#ifdef __MACOS9__
	OSStatus err;
	long gestalt_result;
	OTNotifyUPP notifyUPP;
	EndpointRef ep;
	TEndpointInfo info;
	MacSurfOTState ot_state;
	TBind ret_bind;
	InetAddress ret_addr;
	InetAddress snd_addr;
	InetHost host;
	TCall snd_call;
	EventRecord dummy_event;
	char request[512];
	char *buf;
	char *body;
	long req_len;
	long total;
	long body_len;
	OTResult n;
	char *sep;

	/* 1. Gestalt: is OT TCP present? */
	if (Gestalt(gestaltOpenTpt, &gestalt_result) != noErr ||
	    !(gestalt_result & gestaltOpenTptPresentMask) ||
	    !(gestalt_result & gestaltOpenTptTCPPresentMask)) {
		if (callback) callback(gw, "No OT TCP", 9, -1);
		return;
	}

	/* 2. Init with the real flag (not 0). */
	err = InitOpenTransportInContext(kInitOTForApplicationMask, NULL);
	if (err != noErr) {
		if (callback) callback(gw, "OT init failed", 14, -1);
		return;
	}

	/* 3. UPP for the notifier callback. */
	notifyUPP = NewOTNotifyUPP(macos9_ot_notifier);
	if (notifyUPP == NULL) {
		CloseOpenTransportInContext(NULL);
		if (callback) callback(gw, "OT UPP failed", 13, -1);
		return;
	}

	/* 4. Open endpoint; pass config directly, check err + ep only. */
	ep = OTOpenEndpointInContext(OTCreateConfiguration(kTCPName),
				     0, &info, &err, NULL);
	if (err != noErr || ep == NULL) {
		DisposeOTNotifyUPP(notifyUPP);
		CloseOpenTransportInContext(NULL);
		if (callback) callback(gw, "OT open failed", 14, -1);
		return;
	}

	/* 5. Sync mode first, install notifier, then bind with real TBind. */
	OTMemzero(&ot_state, sizeof(ot_state));
	OTSetSynchronous(ep);
	err = OTInstallNotifier(ep, notifyUPP, &ot_state);
	if (err != noErr) {
		OTCloseProvider(ep);
		DisposeOTNotifyUPP(notifyUPP);
		CloseOpenTransportInContext(NULL);
		if (callback) callback(gw, "OT notifier failed", 18, -1);
		return;
	}

	OTMemzero(&ret_bind, sizeof(TBind));
	ret_bind.addr.maxlen = sizeof(InetAddress);
	ret_bind.addr.buf    = (UInt8 *)&ret_addr;
	err = OTBind(ep, NULL, &ret_bind);
	if (err != noErr) {
		OTCloseProvider(ep);
		DisposeOTNotifyUPP(notifyUPP);
		CloseOpenTransportInContext(NULL);
		if (callback) callback(gw, "OT bind failed", 14, -1);
		return;
	}

	/* 6. Switch async, connect, poll WaitNextEvent. */
	OTInetStringToHost((char *)MACSURF_PROXY_HOST, &host);
	OTInitInetAddress(&snd_addr, MACSURF_PROXY_PORT, host);

	OTMemzero(&snd_call, sizeof(TCall));
	snd_call.addr.buf    = (UInt8 *)&snd_addr;
	snd_call.addr.len    = sizeof(InetAddress);
	snd_call.addr.maxlen = sizeof(InetAddress);

	OTSetAsynchronous(ep);
	err = OTConnect(ep, &snd_call, NULL);
	if (err != kOTNoDataErr && err != noErr) {
		OTCloseProvider(ep);
		DisposeOTNotifyUPP(notifyUPP);
		CloseOpenTransportInContext(NULL);
		if (callback) callback(gw, "OT connect failed", 17, -1);
		return;
	}

	while (!ot_state.connected && !ot_state.terminated) {
		WaitNextEvent(nullEvent, &dummy_event, 1, NULL);
	}

	if (ot_state.terminated) {
		OTCloseProvider(ep);
		DisposeOTNotifyUPP(notifyUPP);
		CloseOpenTransportInContext(NULL);
		if (callback) callback(gw, "OT terminated", 13, -1);
		return;
	}

	OTRcvConnect(ep, NULL);

	/* 7. Back to sync for simple Snd/Rcv. */
	OTSetSynchronous(ep);

	req_len = 0;
	req_len += sprintf(request + req_len, "GET %s HTTP/1.0\r\n", url);
	req_len += sprintf(request + req_len, "User-Agent: MacSurf/0.1\r\n");
	req_len += sprintf(request + req_len, "Connection: close\r\n\r\n");

	n = OTSnd(ep, request, req_len, 0);
	if (n < 0) {
		OTSndOrderlyDisconnect(ep);
		OTCloseProvider(ep);
		DisposeOTNotifyUPP(notifyUPP);
		CloseOpenTransportInContext(NULL);
		if (callback) callback(gw, "OT send failed", 14, -1);
		return;
	}

	buf = (char *)NewPtr(32768);
	if (buf == NULL) {
		OTSndOrderlyDisconnect(ep);
		OTCloseProvider(ep);
		DisposeOTNotifyUPP(notifyUPP);
		CloseOpenTransportInContext(NULL);
		if (callback) callback(gw, "NewPtr failed", 13, -1);
		return;
	}

	total = 0;
	do {
		n = OTRcv(ep, buf + total, 32767 - total, NULL);
		if (n > 0) total += n;
	} while (n > 0 && total < 32767);
	buf[total] = '\0';

	body = buf;
	body_len = total;
	if (total > 0) {
		sep = strstr(buf, "\r\n\r\n");
		if (sep != NULL) {
			body = sep + 4;
			body_len = total - (long)(body - buf);
		}
	}

	if (callback != NULL)
		callback(gw, body, body_len, 0);

	DisposePtr(buf);

	/* 8. Teardown. */
	OTSndOrderlyDisconnect(ep);
	OTCloseProvider(ep);
	DisposeOTNotifyUPP(notifyUPP);
	CloseOpenTransportInContext(NULL);
#else
	if (callback)
		callback(gw, "<h1>Example</h1><p>Stub.</p>", 27, 0);
	(void)url;
	(void)gw;
#endif
}

int macos9_ot_init(void) { return 0; }
const char *macos9_ot_get_error(void) { return NULL; }

struct gui_fetch_table macos9_fetch_table = {
	macos9_fetch_filetype,
	macos9_fetch_get_resource_url,
	NULL,
	NULL,
	macos9_fetch_mimetype,
	NULL,
	NULL
};
