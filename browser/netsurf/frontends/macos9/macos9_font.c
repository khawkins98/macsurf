/*
 * MacSurf - macos9_font.c
 * gui_layout_table callbacks.
 *
 * v0.3 rewrite: deterministic character-width heuristic instead of
 * QuickDraw TextWidth/CharWidth. QuickDraw text measurement reads from
 * the current GrafPort, which is not reliably set during NetSurf layout
 * (layout runs from hlcache callbacks, not from the update event path),
 * so TextWidth was returning 0 and text boxes ended up with zero width.
 *
 * The heuristic returns a plausible width per character based on the
 * requested font size and family. It does not match the actual glyph
 * widths QuickDraw will draw, but layout only needs *monotonic,
 * non-zero, roughly proportional* widths to place text boxes correctly
 * and plot_text will draw whatever fits.
 */

#include <stdlib.h>
#include <string.h>

#include "utils/errors.h"
#include "utils/log.h"
#include "utils/utf8.h"
#include "netsurf/plot_style.h"
#include "netsurf/layout.h"

#include "macos9/macos9.h"

/* Baseline character widths in 1/1024 of the font size.
 * Monospace: 1 em per char is too wide, 0.6 em matches Monaco.
 * Proportional: 0.52 em average matches lowercase-heavy text. */
#define CW_MONO_NUM  614   /* 0.60 * 1024 */
#define CW_PROP_NUM  533   /* 0.52 * 1024 */
#define CW_DEN       1024

static int
mac_char_width(const struct plot_font_style *fstyle){
	int size_px;
	int num;
	int w;

	if (fstyle == NULL)
		size_px = 12;
	else
		size_px = (int)(fstyle->size >> PLOT_STYLE_RADIX);
	if (size_px <= 0) size_px = 12;

	if (fstyle != NULL &&
	    fstyle->family == PLOT_FONT_FAMILY_MONOSPACE)
		num = CW_MONO_NUM;
	else
		num = CW_PROP_NUM;

	w = (size_px * num + CW_DEN / 2) / CW_DEN;
	if (w < 1) w = 1;
	return w;
}

static nserror
macos9_font_width(const struct plot_font_style *fstyle,
		  const char *string,
		  size_t length,
		  int *width){
	int cw;
	if (string == NULL || length == 0) {
		*width = 0;
		return NSERROR_OK;
	}
	cw = mac_char_width(fstyle);
	*width = (int)length * cw;
	return NSERROR_OK;
}

static nserror
macos9_font_position(const struct plot_font_style *fstyle,
		     const char *string,
		     size_t length,
		     int x,
		     size_t *char_offset,
		     int *actual_x){
	int cw;
	size_t n;
	if (string == NULL || length == 0) {
		*char_offset = 0;
		*actual_x = 0;
		return NSERROR_OK;
	}
	cw = mac_char_width(fstyle);
	if (cw <= 0) cw = 1;
	if (x < 0) x = 0;
	n = (size_t)(x / cw);
	if (n > length) n = length;
	*char_offset = n;
	*actual_x = (int)n * cw;
	return NSERROR_OK;
}

static nserror
macos9_font_split(const struct plot_font_style *fstyle,
		  const char *string,
		  size_t length,
		  int x,
		  size_t *char_offset,
		  int *actual_x){
	int cw;
	size_t max_chars;
	size_t last_space;
	size_t i;
	int have_space;

	if (string == NULL || length == 0) {
		*char_offset = 0;
		*actual_x = 0;
		return NSERROR_OK;
	}
	cw = mac_char_width(fstyle);
	if (cw <= 0) cw = 1;
	if (x < 0) x = 0;
	max_chars = (size_t)(x / cw);
	if (max_chars > length) max_chars = length;

	last_space = 0;
	have_space = 0;
	for (i = 0; i < max_chars; i++) {
		if (string[i] == ' ') {
			last_space = i;
			have_space = 1;
		}
	}

	if (have_space) {
		*char_offset = last_space;
		*actual_x = (int)last_space * cw;
	} else {
		/* No break - force at least 1 char progress */
		size_t fit = max_chars;
		if (fit == 0) fit = 1;
		*char_offset = fit;
		*actual_x = (int)fit * cw;
	}
	return NSERROR_OK;
}

/* Field order: width, position, split (see include/netsurf/layout.h) */
static struct gui_layout_table layout_table = {
	macos9_font_width,
	macos9_font_position,
	macos9_font_split
};

struct gui_layout_table *macos9_layout_table = &layout_table;
