/*
 * MacSurf - window.c
 *
 * Carbon window with toolbar (Back / Forward / Reload / Home), a manually
 * drawn URL field, vertical and horizontal scroll bars, content area, and
 * status bar. Rendering flows entirely through the NetSurf core via
 * browser_window_redraw and the macos9 plotter table.
 *
 * Pixel-scroll model: scroll_x / scroll_y are pixel offsets into the
 * rendered content. Whenever NetSurf signals new content or a new
 * extent, browser_window_get_extents is queried and the scroll bars
 * are reranged to match.
 *
 * URL editing remains manual (no TextEdit) - per CLAUDE.md, TENew
 * crashes with dsMemWZErr on a fresh window. Keystrokes append to
 * gui_window::url while gui_window::url_active is true. Return submits
 * via browser_window_navigate; Escape resets the field to the current
 * page URL.
 */

#include <stdlib.h>
#include <string.h>

#include "utils/errors.h"
#include "utils/log.h"
#include "utils/nsurl.h"
#include "netsurf/types.h"
#include "netsurf/window.h"
#include "netsurf/browser_window.h"
#include "desktop/browser_history.h"

#include "macos9/macos9.h"
#include "macsurf_debug.h"

#ifdef __MACOS9__
#include <MacWindows.h>
#include <Controls.h>
#include <Appearance.h>
#include <Quickdraw.h>
#include <TextUtils.h>
#include <Fonts.h>

/* CW8's Controls.h lacks these Appearance Manager CDEF procIDs. */
#ifndef kControlPushButtonProc
#define kControlPushButtonProc    368
#endif
#ifndef kControlScrollBarLiveProc
#define kControlScrollBarLiveProc 386
#endif

/* CW8's Controls.h lacks these part codes. */
#ifndef kControlUpButtonPart
#define kControlUpButtonPart    20
#endif
#ifndef kControlDownButtonPart
#define kControlDownButtonPart  21
#endif
#ifndef kControlPageUpPart
#define kControlPageUpPart      22
#endif
#ifndef kControlPageDownPart
#define kControlPageDownPart    23
#endif
#ifndef kControlIndicatorPart
#define kControlIndicatorPart   129
#endif

/* CW8 expands New/DisposeControlActionUPP into NewRoutineDescriptor /
 * DisposeRoutineDescriptor calls, which are not in CarbonLib. Under
 * Carbon UPPs are just native function pointers, so override the
 * macros. */
#ifdef NewControlActionUPP
#undef NewControlActionUPP
#endif
#ifdef DisposeControlActionUPP
#undef DisposeControlActionUPP
#endif
#define NewControlActionUPP(proc)    ((ControlActionUPP)(proc))
#define DisposeControlActionUPP(upp) ((void)(upp))

#else
/* Linux cross-check stubs. */
#ifndef __MACTYPES__
typedef int OSStatus;
typedef int Boolean;
#endif
typedef short SInt16;
typedef void *CFStringRef;
typedef unsigned char Str255[256];
typedef unsigned long WindowClass;
typedef unsigned long WindowAttributes;
typedef short ControlPartCode;
typedef void (*ControlActionProcPtr)(ControlRef, ControlPartCode);
typedef ControlActionProcPtr ControlActionUPP;
enum { kDocumentWindowClass = 6 };
enum { kWindowStandardDocumentAttributes = 0x1F };
enum { kWindowContentRgn = 33 };
enum { kControlPushButtonProc = 368, kControlScrollBarLiveProc = 386 };
enum { kControlUpButtonPart = 20, kControlDownButtonPart = 21,
	kControlPageUpPart = 22, kControlPageDownPart = 23,
	kControlIndicatorPart = 129 };
#define noErr 0
#define PSTR(s) ((const unsigned char *)(s))
static void SetRect(Rect *r, short l, short t, short rt, short b)
{ r->top=t; r->left=l; r->bottom=b; r->right=rt; }
static OSStatus CreateNewWindow(WindowClass wc, WindowAttributes attr,
		const Rect *b, WindowRef *out)
{ (void)wc;(void)attr;(void)b; static int d; *out=&d; return 0; }
static ControlRef NewControl(WindowRef w, const Rect *b, const unsigned char *t,
		Boolean vis, short v, short min, short max, short proc, long ref)
{ (void)w;(void)b;(void)t;(void)vis;(void)v;(void)min;(void)max;(void)proc;(void)ref; return NULL; }
static void ShowWindow(WindowRef w) { (void)w; }
static void DisposeWindow(WindowRef w) { (void)w; }
static void SetWTitle(WindowRef w, const unsigned char *t) { (void)w;(void)t; }
static void GetWindowBounds(WindowRef w, int rgn, Rect *b)
{ (void)w;(void)rgn; b->top=0;b->left=0;b->bottom=480;b->right=640; }
static void InvalWindowRect(WindowRef w, const Rect *r) { (void)w;(void)r; }
static short GetControlValue(ControlRef c) { (void)c; return 0; }
static short GetControlMaximum(ControlRef c) { (void)c; return 0; }
static void SetControlValue(ControlRef c, short v) { (void)c;(void)v; }
static void SetControlMaximum(ControlRef c, short v) { (void)c;(void)v; }
static void SetControlMinimum(ControlRef c, short v) { (void)c;(void)v; }
static void HiliteControl(ControlRef c, short s) { (void)c;(void)s; }
static void MoveControl(ControlRef c, short h, short v) { (void)c;(void)h;(void)v; }
static void SizeControl(ControlRef c, short h, short v) { (void)c;(void)h;(void)v; }
static void SetWRefCon(WindowRef w, long r) { (void)w;(void)r; }
typedef struct { short v, h; } Point;
static short TrackControl(ControlRef c, Point p, ControlActionUPP a)
{ (void)c;(void)p;(void)a; return 0; }
static WindowRef GetControlOwner(ControlRef c) { (void)c; return NULL; }
#define NewControlActionUPP(proc) ((ControlActionUPP)(proc))
#define DisposeControlActionUPP(upp) ((void)(upp))
#endif

static struct gui_window *window_list = NULL;

/* ---- Internal helpers ---- */

struct gui_window *
macos9_find_window(WindowRef w)
{
	struct gui_window *gw;
	for (gw = window_list; gw != NULL; gw = gw->next) {
		if (gw->window == w)
			return gw;
	}
	return NULL;
}

static void
set_pstring(unsigned char *dst, const char *src, size_t cap)
{
	size_t len;
	(void)cap;
	len = strlen(src);
	if (len > 255) len = 255;
	dst[0] = (unsigned char)len;
	memcpy(dst + 1, src, len);
}

static void
set_status_text(struct gui_window *gw, const char *msg)
{
	if (msg == NULL) { gw->status[0] = '\0'; return; }
	strncpy(gw->status, msg, sizeof(gw->status) - 1);
	gw->status[sizeof(gw->status) - 1] = '\0';
}

static void
set_url_text(struct gui_window *gw, const char *u)
{
	if (u == NULL) {
		gw->url[0] = '\0';
		gw->url_len = 0;
		return;
	}
	strncpy(gw->url, u, MACSURF_URL_MAX - 1);
	gw->url[MACSURF_URL_MAX - 1] = '\0';
	gw->url_len = (short)strlen(gw->url);
}

/* ---- Layout ---- */

void
macos9_window_layout(struct gui_window *gw)
{
	Rect content;
	short win_w, win_h;
	short url_x, url_right;
	short content_bottom;
	short hscroll_top;

	if (gw->window == NULL) return;

	GetWindowBounds(gw->window, kWindowContentRgn, &content);
	win_w = (short)(content.right - content.left);
	win_h = (short)(content.bottom - content.top);

	SetRect(&gw->toolbar_rect, 0, 0, win_w, MACOS9_TOOLBAR_HEIGHT);

	url_x = MACOS9_BTN_GAP
	      + (MACOS9_BTN_WIDTH + MACOS9_BTN_GAP) * 4;
	url_right = (short)(win_w - MACOS9_BTN_GAP);
	SetRect(&gw->url_rect,
		url_x,
		MACOS9_BTN_Y,
		url_right,
		(short)(MACOS9_BTN_Y + MACOS9_BTN_HEIGHT));

	hscroll_top    = (short)(win_h - MACOS9_SCROLLBAR_WIDTH);
	content_bottom = (short)(hscroll_top - MACOS9_STATUS_HEIGHT);

	SetRect(&gw->content_rect,
		0,
		MACOS9_TOOLBAR_HEIGHT,
		(short)(win_w - MACOS9_SCROLLBAR_WIDTH),
		content_bottom);

	SetRect(&gw->status_rect,
		0,
		content_bottom,
		(short)(win_w - MACOS9_SCROLLBAR_WIDTH),
		hscroll_top);

	if (gw->vscroll != NULL) {
		MoveControl(gw->vscroll,
			(short)(win_w - MACOS9_SCROLLBAR_WIDTH),
			(short)(MACOS9_TOOLBAR_HEIGHT - 1));
		SizeControl(gw->vscroll,
			MACOS9_SCROLLBAR_WIDTH + 1,
			(short)(content_bottom - MACOS9_TOOLBAR_HEIGHT + 2));
	}
	if (gw->hscroll != NULL) {
		MoveControl(gw->hscroll,
			(short)-1,
			hscroll_top);
		SizeControl(gw->hscroll,
			(short)(win_w - MACOS9_SCROLLBAR_WIDTH + 2),
			MACOS9_SCROLLBAR_WIDTH + 1);
	}
}

/* ---- Invalidation ---- */

void
macos9_window_invalidate_all(struct gui_window *gw)
{
	Rect r;
	if (gw->window == NULL) return;
	GetWindowBounds(gw->window, kWindowContentRgn, &r);
	r.right -= r.left;
	r.bottom -= r.top;
	r.left = 0;
	r.top = 0;
	InvalWindowRect(gw->window, &r);
}

void
macos9_window_invalidate_url(struct gui_window *gw)
{
	if (gw->window == NULL) return;
	InvalWindowRect(gw->window, &gw->url_rect);
}

void
macos9_window_invalidate_content(struct gui_window *gw)
{
	if (gw->window == NULL) return;
	InvalWindowRect(gw->window, &gw->content_rect);
}

void
macos9_window_invalidate_status(struct gui_window *gw)
{
	if (gw->window == NULL) return;
	InvalWindowRect(gw->window, &gw->status_rect);
}

/* ---- Extents and scroll bars ---- */

static int
content_view_width(struct gui_window *gw)
{
	int w = gw->content_rect.right - gw->content_rect.left;
	if (w < 1) w = 1;
	return w;
}

static int
content_view_height(struct gui_window *gw)
{
	int h = gw->content_rect.bottom - gw->content_rect.top;
	if (h < 1) h = 1;
	return h;
}

void
macos9_window_update_extents(struct gui_window *gw)
{
	int w = 0;
	int h = 0;
	if (gw->bw != NULL) {
		if (browser_window_get_extents(gw->bw, false, &w, &h) == NSERROR_OK) {
			gw->content_width = w;
			gw->content_height = h;
		}
	}
	macos9_window_update_scrollbars(gw);
}

void
macos9_window_update_scrollbars(struct gui_window *gw)
{
	int view_w, view_h;
	int max_x, max_y;
	short cmax_x, cmax_y;

	view_w = content_view_width(gw);
	view_h = content_view_height(gw);

	max_x = gw->content_width  - view_w;
	max_y = gw->content_height - view_h;
	if (max_x < 0) max_x = 0;
	if (max_y < 0) max_y = 0;

	if (gw->scroll_x > max_x) gw->scroll_x = max_x;
	if (gw->scroll_y > max_y) gw->scroll_y = max_y;
	if (gw->scroll_x < 0) gw->scroll_x = 0;
	if (gw->scroll_y < 0) gw->scroll_y = 0;

	/* Carbon SetControlMaximum takes a short - clamp. */
	cmax_x = (short)(max_x > 32000 ? 32000 : max_x);
	cmax_y = (short)(max_y > 32000 ? 32000 : max_y);

	if (gw->vscroll != NULL) {
		SetControlMinimum(gw->vscroll, 0);
		SetControlMaximum(gw->vscroll, cmax_y);
		SetControlValue(gw->vscroll, (short)gw->scroll_y);
		HiliteControl(gw->vscroll, (short)(max_y > 0 ? 0 : 255));
	}
	if (gw->hscroll != NULL) {
		SetControlMinimum(gw->hscroll, 0);
		SetControlMaximum(gw->hscroll, cmax_x);
		SetControlValue(gw->hscroll, (short)gw->scroll_x);
		HiliteControl(gw->hscroll, (short)(max_x > 0 ? 0 : 255));
	}
}

void
macos9_window_scroll_to(struct gui_window *gw, int new_x, int new_y)
{
	int max_x, max_y;
	int view_w, view_h;

	view_w = content_view_width(gw);
	view_h = content_view_height(gw);

	max_x = gw->content_width  - view_w;
	max_y = gw->content_height - view_h;
	if (max_x < 0) max_x = 0;
	if (max_y < 0) max_y = 0;

	if (new_x < 0) new_x = 0;
	if (new_y < 0) new_y = 0;
	if (new_x > max_x) new_x = max_x;
	if (new_y > max_y) new_y = max_y;

	if (new_x == gw->scroll_x && new_y == gw->scroll_y) return;

	gw->scroll_x = new_x;
	gw->scroll_y = new_y;

	if (gw->vscroll != NULL) SetControlValue(gw->vscroll, (short)new_y);
	if (gw->hscroll != NULL) SetControlValue(gw->hscroll, (short)new_x);

	macos9_window_invalidate_content(gw);
}

void
macos9_window_scroll_by(struct gui_window *gw, int dx, int dy)
{
	macos9_window_scroll_to(gw, gw->scroll_x + dx, gw->scroll_y + dy);
}

/* ---- Scroll action proc ----
 *
 * No `pascal` qualifier: under Carbon, ControlActionUPPs are native
 * function pointers. The CW8 macro override above neutralises
 * NewControlActionUPP / DisposeControlActionUPP so we don't fall
 * through to NewRoutineDescriptor (which CarbonLib does not export).
 */

#ifdef __MACOS9__

static void
scroll_action(ControlRef ctrl, ControlPartCode part)
{
	WindowRef win;
	struct gui_window *gw;
	int delta;
	int view_w, view_h;
	int new_x, new_y;
	int is_vertical;

	win = (WindowRef)GetControlOwner(ctrl);
	gw = macos9_find_window(win);
	if (gw == NULL) return;

	is_vertical = (ctrl == gw->vscroll);
	view_w = content_view_width(gw);
	view_h = content_view_height(gw);

	switch (part) {
	case kControlUpButtonPart:    delta = -MACOS9_KEY_SCROLL_STEP; break;
	case kControlDownButtonPart:  delta =  MACOS9_KEY_SCROLL_STEP; break;
	case kControlPageUpPart:      delta = -((is_vertical ? view_h : view_w) - 32); break;
	case kControlPageDownPart:    delta =   (is_vertical ? view_h : view_w) - 32; break;
	default: return;
	}
	if (is_vertical) {
		new_x = gw->scroll_x;
		new_y = gw->scroll_y + delta;
	} else {
		new_x = gw->scroll_x + delta;
		new_y = gw->scroll_y;
	}
	macos9_window_scroll_to(gw, new_x, new_y);
}

#endif

/*
 * Click-driven scroll: install our action proc for arrow / page parts
 * (so CarbonLib auto-repeats them while the mouse is held), then sync
 * the final scroll position from the live thumb after TrackControl
 * returns. With the kControlScrollBarLiveProc CDEF the thumb already
 * updates the control value continuously during drag.
 */
void
macos9_window_handle_scrollbar_click(struct gui_window *gw,
		ControlRef ctrl, void *local_pt)
{
#ifdef __MACOS9__
	ControlActionUPP action;
	short thumb_x, thumb_y;
	Point pt;

	if (gw == NULL || ctrl == NULL) return;
	if (local_pt == NULL) return;

	pt = *(Point *)local_pt;
	action = NewControlActionUPP(scroll_action);
	(void)TrackControl(ctrl, pt, action);
	DisposeControlActionUPP(action);

	thumb_x = (gw->hscroll != NULL) ? GetControlValue(gw->hscroll) : (short)gw->scroll_x;
	thumb_y = (gw->vscroll != NULL) ? GetControlValue(gw->vscroll) : (short)gw->scroll_y;
	macos9_window_scroll_to(gw, (int)thumb_x, (int)thumb_y);
#else
	(void)gw; (void)ctrl; (void)local_pt;
#endif
}

/* ---- Navigation ---- */

void
macos9_window_navigate(struct gui_window *gw, const char *url)
{
	nsurl *nsu;
	nserror err;

	if (gw == NULL || url == NULL || url[0] == '\0') return;

	set_url_text(gw, url);
	gw->url_active = false;
	set_status_text(gw, "Loading...");
	macos9_window_invalidate_url(gw);
	macos9_window_invalidate_status(gw);

	if (gw->bw == NULL) return;

	err = nsurl_create(url, &nsu);
	if (err != NSERROR_OK) {
		MS_LOG("nav: nsurl_create failed");
		return;
	}
	err = browser_window_navigate(gw->bw, nsu, NULL,
			BW_NAVIGATE_HISTORY, NULL, NULL, NULL);
	nsurl_unref(nsu);
	if (err != NSERROR_OK) {
		MS_LOG("nav: browser_window_navigate failed");
	}
}

void
macos9_window_address_bar_submit(struct gui_window *gw)
{
	char buf[MACSURF_URL_MAX + 8];
	if (gw == NULL) return;
	if (gw->url_len <= 0) return;

	if (strstr(gw->url, "://") == NULL) {
		strcpy(buf, "http://");
		strncat(buf, gw->url, MACSURF_URL_MAX - 1);
	} else {
		strncpy(buf, gw->url, sizeof(buf) - 1);
		buf[sizeof(buf) - 1] = '\0';
	}
	macos9_window_navigate(gw, buf);
}

void
macos9_window_back(struct gui_window *gw)
{
	if (gw == NULL || gw->bw == NULL) return;
	if (browser_window_history_back_available(gw->bw)) {
		browser_window_history_back(gw->bw, false);
		macos9_window_update_button_states(gw);
	}
}

void
macos9_window_forward(struct gui_window *gw)
{
	if (gw == NULL || gw->bw == NULL) return;
	if (browser_window_history_forward_available(gw->bw)) {
		browser_window_history_forward(gw->bw, false);
		macos9_window_update_button_states(gw);
	}
}

void
macos9_window_reload(struct gui_window *gw)
{
	if (gw == NULL || gw->bw == NULL) return;
	browser_window_reload(gw->bw, true);
}

void
macos9_window_home(struct gui_window *gw)
{
	macos9_window_navigate(gw, MACSURF_HOME_URL);
}

void
macos9_window_update_button_states(struct gui_window *gw)
{
	short back_h, fwd_h;
	if (gw == NULL || gw->bw == NULL) return;

	back_h = browser_window_history_back_available(gw->bw)    ? (short)0 : (short)255;
	fwd_h  = browser_window_history_forward_available(gw->bw) ? (short)0 : (short)255;
	if (gw->back_btn    != NULL) HiliteControl(gw->back_btn,    back_h);
	if (gw->forward_btn != NULL) HiliteControl(gw->forward_btn, fwd_h);
	if (gw->reload_btn  != NULL) HiliteControl(gw->reload_btn,  0);
	if (gw->home_btn    != NULL) HiliteControl(gw->home_btn,    0);
}

/* ---- Resize ---- */

void
macos9_window_resize(struct gui_window *gw)
{
	if (gw == NULL) return;
	macos9_window_layout(gw);
	if (gw->bw != NULL) {
		(void)browser_window_schedule_reformat(gw->bw);
	}
	macos9_window_update_scrollbars(gw);
	macos9_window_invalidate_all(gw);
}

/* ---- Window creation ---- */

static struct gui_window *
macos9_window_create(struct browser_window *bw,
		struct gui_window *existing,
		gui_window_create_flags flags)
{
	struct gui_window *gw;
	Rect bounds;
	Rect btn_rect;
	Rect sb_rect;
	OSStatus err;
	short x;

	(void)existing;
	(void)flags;

	gw = calloc(1, sizeof(*gw));
	if (gw == NULL) return NULL;

	gw->bw = bw;

#ifdef __MACOS9__
	SetRect(&bounds, 40, 50, 640, 470);
#else
	bounds.left = 40; bounds.top = 50;
	bounds.right = 640; bounds.bottom = 470;
#endif

	err = CreateNewWindow(kDocumentWindowClass,
			kWindowStandardDocumentAttributes,
			&bounds, &gw->window);
	if (err != noErr) {
		free(gw);
		return NULL;
	}

#ifdef __MACOS9__
	SetWTitle(gw->window, "\pMacSurf");
	SetWRefCon(gw->window, (long)gw);
#else
	SetWTitle(gw->window, PSTR("MacSurf"));
#endif

	x = MACOS9_BTN_GAP;

	SetRect(&btn_rect, x, MACOS9_BTN_Y,
		(short)(x + MACOS9_BTN_WIDTH),
		(short)(MACOS9_BTN_Y + MACOS9_BTN_HEIGHT));
	gw->back_btn = NewControl(gw->window, &btn_rect,
#ifdef __MACOS9__
			"\pBack",
#else
			PSTR("Back"),
#endif
			true, 0, 0, 1, kControlPushButtonProc, (long)gw);
	x = (short)(x + MACOS9_BTN_WIDTH + MACOS9_BTN_GAP);

	SetRect(&btn_rect, x, MACOS9_BTN_Y,
		(short)(x + MACOS9_BTN_WIDTH),
		(short)(MACOS9_BTN_Y + MACOS9_BTN_HEIGHT));
	gw->forward_btn = NewControl(gw->window, &btn_rect,
#ifdef __MACOS9__
			"\pFwd",
#else
			PSTR("Fwd"),
#endif
			true, 0, 0, 1, kControlPushButtonProc, (long)gw);
	x = (short)(x + MACOS9_BTN_WIDTH + MACOS9_BTN_GAP);

	SetRect(&btn_rect, x, MACOS9_BTN_Y,
		(short)(x + MACOS9_BTN_WIDTH),
		(short)(MACOS9_BTN_Y + MACOS9_BTN_HEIGHT));
	gw->reload_btn = NewControl(gw->window, &btn_rect,
#ifdef __MACOS9__
			"\pReload",
#else
			PSTR("Reload"),
#endif
			true, 0, 0, 1, kControlPushButtonProc, (long)gw);
	x = (short)(x + MACOS9_BTN_WIDTH + MACOS9_BTN_GAP);

	SetRect(&btn_rect, x, MACOS9_BTN_Y,
		(short)(x + MACOS9_BTN_WIDTH),
		(short)(MACOS9_BTN_Y + MACOS9_BTN_HEIGHT));
	gw->home_btn = NewControl(gw->window, &btn_rect,
#ifdef __MACOS9__
			"\pHome",
#else
			PSTR("Home"),
#endif
			true, 0, 0, 1, kControlPushButtonProc, (long)gw);

	/* Vertical scrollbar - right edge, between toolbar and status bar. */
	SetRect(&sb_rect,
		(short)(bounds.right - bounds.left - MACOS9_SCROLLBAR_WIDTH),
		(short)(MACOS9_TOOLBAR_HEIGHT - 1),
		(short)(bounds.right - bounds.left + 1),
		(short)(bounds.bottom - bounds.top
			- MACOS9_SCROLLBAR_WIDTH - MACOS9_STATUS_HEIGHT + 2));
	gw->vscroll = NewControl(gw->window, &sb_rect,
#ifdef __MACOS9__
			"\p",
#else
			PSTR(""),
#endif
			true, 0, 0, 0, kControlScrollBarLiveProc, (long)gw);

	/* Horizontal scrollbar - bottom edge, full width minus vscroll corner. */
	SetRect(&sb_rect,
		-1,
		(short)(bounds.bottom - bounds.top - MACOS9_SCROLLBAR_WIDTH),
		(short)(bounds.right - bounds.left
			- MACOS9_SCROLLBAR_WIDTH + 1),
		(short)(bounds.bottom - bounds.top + 1));
	gw->hscroll = NewControl(gw->window, &sb_rect,
#ifdef __MACOS9__
			"\p",
#else
			PSTR(""),
#endif
			true, 0, 0, 0, kControlScrollBarLiveProc, (long)gw);

	set_url_text(gw, MACSURF_HOME_URL);
	gw->url_active = false;
	gw->url_scroll = 0;

	gw->scroll_x = 0;
	gw->scroll_y = 0;
	gw->content_width = 0;
	gw->content_height = 0;

	set_status_text(gw, "Ready");

	macos9_window_layout(gw);
	macos9_window_update_scrollbars(gw);
	macos9_window_update_button_states(gw);

	ShowWindow(gw->window);

	gw->next = window_list;
	window_list = gw;

	return gw;
}

void
macos9_window_destroy(struct gui_window *gw)
{
	struct gui_window **p;

	for (p = &window_list; *p != NULL; p = &(*p)->next) {
		if (*p == gw) {
			*p = gw->next;
			break;
		}
	}

	if (gw->window != NULL)
		DisposeWindow(gw->window);

	free(gw);
}

/* ---- gui_window_table callbacks ---- */

static nserror
macos9_gw_invalidate(struct gui_window *gw, const struct rect *rect)
{
	(void)rect;
	MS_LOG("gui inv");
	macos9_window_invalidate_content(gw);
	return NSERROR_OK;
}

static bool
macos9_gw_get_scroll(struct gui_window *gw, int *sx, int *sy)
{
	if (sx) *sx = gw->scroll_x;
	if (sy) *sy = gw->scroll_y;
	return true;
}

static nserror
macos9_gw_set_scroll(struct gui_window *gw, const struct rect *rect)
{
	if (rect != NULL) {
		macos9_window_scroll_to(gw, rect->x0, rect->y0);
	}
	return NSERROR_OK;
}

static nserror
macos9_gw_get_dimensions(struct gui_window *gw, int *width, int *height)
{
	MS_LOG("gui dim");
	if (width)  *width  = gw->content_rect.right - gw->content_rect.left;
	if (height) *height = gw->content_rect.bottom - gw->content_rect.top;
	return NSERROR_OK;
}

static nserror
macos9_gw_event(struct gui_window *gw, enum gui_window_event event)
{
	MS_LOG("gui evt");
	switch (event) {
	case GW_EVENT_UPDATE_EXTENT:
	case GW_EVENT_NEW_CONTENT:
		macos9_window_update_extents(gw);
		macos9_window_update_button_states(gw);
		macos9_window_invalidate_all(gw);
		break;
	case GW_EVENT_STOP_THROBBER:
		set_status_text(gw, "Done");
		macos9_window_invalidate_status(gw);
		break;
	case GW_EVENT_START_THROBBER:
		set_status_text(gw, "Loading...");
		macos9_window_invalidate_status(gw);
		break;
	default:
		break;
	}
	return NSERROR_OK;
}

static void
macos9_gw_set_title(struct gui_window *gw, const char *title)
{
	Str255 ptitle;
	if (gw == NULL || gw->window == NULL || title == NULL) return;
#ifdef MACSURF_DEBUG
	if (macsurf_debug_title_is_locked()) return;
#endif
	set_pstring(ptitle, title, sizeof(ptitle));
	SetWTitle(gw->window, ptitle);
}

static nserror
macos9_gw_set_url(struct gui_window *gw, struct nsurl *url)
{
	const char *u;
	if (gw == NULL || url == NULL) return NSERROR_OK;
	u = nsurl_access(url);
	if (u == NULL) return NSERROR_OK;
	set_url_text(gw, u);
	macos9_window_invalidate_url(gw);
	return NSERROR_OK;
}

static void
macos9_gw_set_icon(struct gui_window *g, struct hlcache_handle *i)
{ (void)g; (void)i; }

static void
macos9_gw_set_status(struct gui_window *g, const char *text)
{
	MS_LOG("gui stat");
	if (g == NULL || text == NULL) return;
	set_status_text(g, text);
	macos9_window_invalidate_status(g);
}

static void
macos9_gw_set_pointer(struct gui_window *g, enum gui_pointer_shape s)
{ (void)g; (void)s; }

static void
macos9_gw_place_caret(struct gui_window *g, int x, int y, int h,
		const struct rect *clip)
{ (void)g;(void)x;(void)y;(void)h;(void)clip; }

static bool
macos9_gw_drag_start(struct gui_window *g, gui_drag_type t,
		const struct rect *r)
{ (void)g;(void)t;(void)r; return false; }

static nserror
macos9_gw_save_link(struct gui_window *g, struct nsurl *u, const char *t)
{ (void)g;(void)u;(void)t; return NSERROR_OK; }

static void
macos9_gw_create_form_select_menu(struct gui_window *g,
		struct form_control *c)
{ (void)g;(void)c; }

static void
macos9_gw_file_gadget_open(struct gui_window *g,
		struct hlcache_handle *h, struct form_control *f)
{ (void)g;(void)h;(void)f; }

static void
macos9_gw_drag_save_object(struct gui_window *g,
		struct hlcache_handle *c, gui_save_type t)
{ (void)g;(void)c;(void)t; }

static void
macos9_gw_drag_save_selection(struct gui_window *g, const char *s)
{ (void)g;(void)s; }

static void
macos9_gw_console_log(struct gui_window *g,
		browser_window_console_source src, const char *m, size_t l,
		browser_window_console_flags f)
{ (void)g;(void)src;(void)m;(void)l;(void)f; }

struct gui_window *
macos9_create_initial_window(void)
{
	return macos9_window_create(NULL, NULL, 0);
}

static struct gui_window_table window_table = {
	macos9_window_create,
	macos9_window_destroy,
	macos9_gw_invalidate,
	(unsigned char (*)(struct gui_window *, int *, int *))
		macos9_gw_get_scroll,
	macos9_gw_set_scroll,
	macos9_gw_get_dimensions,
	macos9_gw_event,
	macos9_gw_set_title,
	macos9_gw_set_url,
	macos9_gw_set_icon,
	macos9_gw_set_status,
	macos9_gw_set_pointer,
	macos9_gw_place_caret,
	(unsigned char (*)(struct gui_window *, gui_drag_type, const struct rect *))
		macos9_gw_drag_start,
	macos9_gw_save_link,
	macos9_gw_create_form_select_menu,
	macos9_gw_file_gadget_open,
	macos9_gw_drag_save_object,
	macos9_gw_drag_save_selection,
	macos9_gw_console_log
};

struct gui_window_table *macos9_window_table = &window_table;
